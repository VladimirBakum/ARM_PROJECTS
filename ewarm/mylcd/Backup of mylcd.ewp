# IAR project Backup of mylcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\StellarisWare\
  ICCARM.CCOptLevel: 3
  AARM.ADefines: ewarm
  AARM.AUserIncludes: c:\StellarisWare\
  OBJCOPY.OOCOutputFile: mylcd.bin
  ILINK.IlinkOutputFile: mylcd.out
  ILINK.IlinkIcfFile: mylcd.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    C:/StellarisWare/driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source
    ./: main.c startup_ewarm.c
    C:/StellarisWare/utils/: uartstdio.c ustdlib.c
