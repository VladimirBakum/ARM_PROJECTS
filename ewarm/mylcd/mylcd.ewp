# IAR project mylcd.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA2
  ICCARM.CCIncludePath2: C:\StellarisWare\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: C:\StellarisWare\
  OBJCOPY.OOCOutputFile: mylcd.bin
  ILINK.IlinkOutputFile: mylcd.out
  ILINK.IlinkIcfFile: mylcd.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    C:/StellarisWare/driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source
    ./: main.c startup_ewarm.c
    utils/: uartstdio.c
    C:/StellarisWare/utils/: ustdlib.c
