# IAR project 1602_lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\examples\TexasInstruments\Stellaris\
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 1602_lcd.bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lcd_1602_lm4f.c main.c pll.c startup_ewarm.c systick.c
